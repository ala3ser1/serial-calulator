# Keil uVision project NEW.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: NEW +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: adc.c adc.h cal.c cal.h interface.c keypad.c keypad.h lcd.c lcd.h spi_interface.c
